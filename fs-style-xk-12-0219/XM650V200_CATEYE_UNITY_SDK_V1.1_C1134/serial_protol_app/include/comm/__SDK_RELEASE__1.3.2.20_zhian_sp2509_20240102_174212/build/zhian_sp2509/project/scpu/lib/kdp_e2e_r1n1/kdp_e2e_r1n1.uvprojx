# Keil uVision project kdp_e2e_r1n1.uvprojx, settings and files
target kdp_e2e_r1n1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.5.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: kdp_e2e_r1n1 (library)
  BeforeMake: ..\..\before_build.bat "$KARM\Flash" @p
  AfterMake: post_build.bat
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: ARM_MATH_CM4, TARGET_SCPU, LOG_ENABLE, KL520, HEAD_POSE_CHECK_PERCENT
  c include: ..\..\..\..\config;..\..\..\..\..\..\board;..\..\..\..\..\..\common\include;..\..\..\..\..\..\scpu\include;..\..\..\..\..\..\scpu\device\include\Kneron;..\..\..\..\..\..\scpu\framework\include;..\..\..\..\..\..\scpu\framework\include\framework;..\..\..\..\..\..\scpu\drivers\include\;..\..\..\..\..\..\scpu\lib\kdp_e2e_r1n1\include;..\..\..\..\..\..\scpu\lib\kdp_application\include;..\..\..\..\..\..\scpu\lib\kdp_application\app;..\..\..\..\..\..\scpu\lib\kdp_application\base;..\..\..\..\..\..\scpu\lib\kdp_application\misc;..\..\..\..\user
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group src
    ../../../../../../scpu/lib/kdp_e2e_r1n1/src/: kdp_e2e_r1n1.c kdp_e2e_n1r1.c kdp_e2e_camera.c kdp_e2e_ctrl.c kdp_e2e_util.c kdp_e2e_face.c kdp_e2e_db.c kdp_e2e_prop.c kdp_e2e_settings.c kdp_e2e_n1_only.c kdp_e2e_r1_only.c
software components: CMSIS:CORE 5.2.0, CMSIS:RTOS2:Keil RTX5 5.5.0, Device:Startup 1.1.0
