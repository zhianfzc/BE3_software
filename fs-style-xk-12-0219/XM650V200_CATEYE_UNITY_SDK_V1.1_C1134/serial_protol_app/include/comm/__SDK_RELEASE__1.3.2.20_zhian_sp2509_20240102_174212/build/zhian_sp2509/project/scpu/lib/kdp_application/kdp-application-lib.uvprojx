# Keil uVision project kdp-application-lib.uvprojx, settings and files
target kdp-application.lib (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.5.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: kdp-application (library)
  BeforeMake: ..\..\before_build.bat "$KARM\Flash" @p
  AfterMake: post_build.bat
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: ARM_MATH_CM4, TARGET_SCPU, KL520, LOG_ENABLE,HEAD_POSE_CHECK_PERCENT
  c include: ..\..\..\..\config;..\..\..\..\..\..\board;..\..\..\..\..\..\common\include;..\..\..\..\..\..\scpu\framework\include\framework;..\..\..\..\..\..\scpu\device\include\Kneron;..\..\..\..\..\..\scpu\drivers\include\;..\..\..\..\..\..\scpu\lib\kdp_application\include;..\..\..\..\..\..\scpu\lib\kdp_application\misc;..\..\..\..\..\..\scpu\device\include\CMSIS;..\..\..\..\..\..\scpu\lib\kdp_e2e_r1n1\include;..\..\..\..\..\..\scpu\share;..\..\..\..\..\..\scpu\framework\include;..\..\..\..\..\..\scpu\include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group app
    ../../../../../../scpu/lib/kdp_application/app/: kdp_model.c kdp_app.c kdp_app_age_gender.c kdp_app_db.c kdp_app_dme.c kdp_app_fid.c kdp_com.c
  group misc
    ../../../../../../scpu/lib/kdp_application/misc/: kdp_memory.c
software components: CMSIS:CORE 5.2.0, CMSIS:RTOS2:Keil RTX5 5.5.0
