# Keil uVision project kdp_system.uvprojx, settings and files
target kdp_system (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.5.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: kdp_system (library)
  AfterMake: post_build.bat
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: ARM_MATH_CM4, TARGET_SCPU, LOG_ENABLE, KL520
  c include: ..\..\..\..\..\..\scpu\lib\kdp_system\inc;..\..\..\..\..\..\scpu\drivers\include;..\..\..\..\..\..\common\include;..\..\..\..\..\..\scpu\device\include\Kneron\
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group src
    ../../../../../../scpu/lib/kdp_system/src/: efuse.c cpu.c bootloader.c
software components: CMSIS:CORE 5.2.0, CMSIS:RTOS2:Keil RTX5 5.5.0
