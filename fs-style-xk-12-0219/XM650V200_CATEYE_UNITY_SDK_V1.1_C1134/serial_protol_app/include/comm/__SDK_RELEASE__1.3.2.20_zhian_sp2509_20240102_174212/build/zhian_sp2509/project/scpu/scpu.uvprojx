# Keil uVision project scpu.uvprojx, settings and files
target Target-scpu (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: scpu +hex
  BeforeMake: before_build.bat "$KARM\Flash" @p
  AfterMake: fromelf.exe --bin ".\Objects\@L.axf" --output ".\Objects\fw_scpu_tmp.bin"
  AfterMake: post_build.bat @p
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: ARM_MATH_CM4, TARGET_SCPU, LOG_ENABLE, KL520, HEAD_POSE_CHECK_PERCENT
  c misc: --gnu
  c include: ..\..\config;..\..\..\..\board;..\..\..\..\common\include;..\..\..\..\scpu\device\include\CMSIS;..\..\..\..\scpu\device\include\Kneron;..\..\..\..\scpu\framework\include;..\..\..\..\scpu\framework\include\framework;..\..\..\..\scpu\drivers\include;..\..\..\..\scpu\drivers\include\media\touch;..\..\..\..\scpu\drivers\include\media\flash;..\..\..\..\scpu\lib\kdp_system\inc;..\..\..\..\scpu\lib\kdp_application\include\;..\..\..\..\scpu\lib\kdp_application\base\;..\..\..\..\scpu\lib\kdp_application\misc;..\..\..\..\scpu\lib\kdp_e2e_r1n1\include;..\..\..\..\scpu\include;..\..\..\..\scpu\middleware\ota;..\..\..\..\scpu\middleware\comm;..\..\..\..\scpu\middleware\kdp_comm;..\..\..\..\scpu\share;..\..\..\..\scpu\share\gui_lib;..\..\user
  library: MicroLIB
  memory RVCT4: ROM 0x10100000 size 0x16000
  memory RVCT9: RAM 0x10200000 size 0x16000
  scatter file: ..\..\..\..\scpu\kl520_96.sct
  link misc: --any_contingency --info=any
  group common
    ../../../../common/src/: delay.c scu_ipc.c
  group share
    ../../../../scpu/share/: board_kl520.c kl520_api.c kl520_api_camera.c kl520_api_fdfr.c kl520_api_system.c kl520_api_snapshot.c kl520_api_sim.c kl520_api_ssp.c kl520_api_extra_fmap.c sample_app_console.c sample_app_touch.c sample_app_spi.c dbg.c version.c sample_user_com_and_gui_fdr.c sample_gui_fsm_events.c sample_gui_main.c
  group user
    ../../user/: main.c pinmux.c user_io.c user_ui.c
    ../: board.cfg
    ../../../../utils/board_gen/: version.cfg
  group drivers
    ../../../../scpu/drivers/src/: ddr.c kdp_memxfer.c kdp_uart.c kdp520_gpio.c kdp520_i2c.c kdp520_ssp.c kdp520_spi.c kdp520_pwm_timer.c kdp520_dma.c kdp520_flash.c kdp520_tmr.c kdp520_adc.c kdp520_usbd.c
    ../../../../scpu/drivers/media/platform/: kdp_fb_mgr.c
    ../../../../scpu/drivers/system/: kdp_crc.c
  group drivers_system
    ../../../../scpu/drivers/system/: clock.c power.c power_manager.c rtc.c system.c mpu.c
  group drivers_base
    ../../../../scpu/drivers/base/: drivers.c
  group drivers_media_v2k
    ../../../../scpu/drivers/media/v2k_core/: media.c
  group drivers_media_platform
    ../../../../scpu/drivers/media/platform/: kdp520_virtual_dp.c kdp520_lcm.c kdp520_lcdc.c kdp520_touch.c kdp_camera.c kdp_camera_kl520.c kdp_sensor.c
  group drivers_media_sensor
    ../../../../scpu/drivers/media/sensor/: sp2509.c
  group drivers_media_display
    ../../../../scpu/drivers/media/display/: display.c video_renderer.c
  group drivers_media_panel
    ../../../../scpu/drivers/media/panel/: virtual_dp.c st7789_240x320.c mzt_480x272.c
  group drivers_media_flash
    ../../../../scpu/drivers/media/flash/: flash.c GD25Q256D.c W25Q256JV.c GD25S512MD.c
  group drivers_media_touch
    ../../../../scpu/drivers/media/touch/: ct130.c touch.c
  group framework
    ../../../../scpu/framework/src/: event.c kdp_list.c mutex.c kdp_prof.c
  group middleware
    ../../../../scpu/middleware/ota/: ota_update.c ota.c
    ../../../../scpu/middleware/comm/: host_com.c host_msg.c host_uart_com.c host_usb_com.c kl520_com.c
  group middleware_kdp_comm
    ../../../../scpu/middleware/kdp_comm/: kdp_comm.c kdp_comm_aes.c kdp_comm_and_gui_fdr.c kdp_comm_app.c kdp_comm_md5.c kdp_comm_protoco.c kdp_comm_utils.c kdp_host_com.c
  group libs
    ./lib/output/: kdp-application.lib kdp_system.lib kdp_e2e_r1n1.lib
  group gui
    ../../../../scpu/share/gui_lib/: gui_base.c gui_fsm.c gui_keypad.c gui_mvc.c gui_text.c gui_text_btn.c
software components: CMSIS:CORE 5.6.0, CMSIS:RTOS2:Keil RTX5 5.5.4, Device:Startup 1.2.2
